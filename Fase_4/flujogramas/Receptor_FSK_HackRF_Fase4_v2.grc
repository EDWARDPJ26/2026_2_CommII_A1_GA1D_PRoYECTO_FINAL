options:
  parameters:
    comment: 'Receptor FSK con HackRF One (Tx: USRP 2920)'
    description: Receptor FSK con instrumentacion BER (e_EbN0_Sweep + e_BER_Curve) y verificacion del texto de telemetria
    generate_options: qt_gui
    id: Receptor_FSK_HackRF_Fase4_v2
    output_language: python
    title: 'Receptor FSK - HackRF One (Fase 4 v2: medicion BER, Rx liviano)'
  states: {}

blocks:
- name: EbN0_max
  id: variable
  parameters:
    comment: Subido de 14 a 18 dB para cruzar BER = 1e-3 con margen
    value: '18'
  states: {}
- name: EbN0_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: EbN0_step
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: N_EbN0
  id: variable
  parameters:
    value: int(round((EbN0_max-EbN0_min)/EbN0_step))+1
  states: {}
- name: Rb
  id: variable
  parameters:
    comment: 'BFSK: Rb = Rs = 10 kbps'
    value: symbol_rate
  states: {}
- name: bb_rate
  id: variable
  parameters:
    comment: Tasa I/Q a la entrada del Rx digital (1 MS/s)
    value: samp_rate
  states: {}
- name: bits_guardia
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: bits_por_punto
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: delay_bits
  id: variable
  parameters:
    comment: 'Queda en 0: e_Ref_Alineada entrega la referencia ya alineada'
    value: '0'
  states: {}
- name: estado_probe
  id: variable_function_probe
  parameters:
    block_id: e_Texto_Rx
    function_name: estado
    poll_rate: '4'
    value: '""'
  states: {}
- name: estado_rx
  id: variable_qtgui_label
  parameters:
    label: Verificacion
    type: string
    value: estado_probe
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Debe ser igual a la del transmisor
    value: 870e6
  states: {}
- name: freq_corr
  id: variable_qtgui_range
  parameters:
    comment: |-
      Corrige el error de cristal entre
      USRP y HackRF (puede ser de varios kHz)
    label: Corrección de frecuencia (Hz)
    start: '-40000'
    step: '100'
    stop: '40000'
    value: '-6500'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    comment: Igual al transmisor
    value: 20e3
  states: {}
- name: hackrf_rate
  id: variable
  parameters:
    comment: Tasa del HackRF (minimo 2 MS/s)
    value: 4e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia LNA (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: lo_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      El HackRF se sintoniza lo_offset abajo de fc.
      Deslizar para alejar su pico de DC de la senal
    label: Desplazamiento del pico DC del HackRF (Hz)
    start: '0'
    step: '10000'
    stop: '2000000'
    value: '200000'
  states: {}
- name: mensaje
  id: variable
  parameters:
    comment: 'Lecturas simuladas FIJAS: el receptor debe conocer el mismo texto'
    value: '"ID:S01;T:24.5C;HR:15%;ALT:2500msnm;P:184kPa;NIV:72%;Q:3.4m3/h"'
  states: {}
- name: pn9
  id: variable
  parameters:
    comment: |-
      0 = carga ASCII sin blanqueo
      1 = carga blanqueada con PN9
      Debe valer lo mismo en el Tx y en el Rx
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Igual a la del transmisor (1 MS/s)
    value: hackrf_rate/decim
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Igual al transmisor
    value: '100'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: texto_probe
  id: variable_function_probe
  parameters:
    block_id: e_Texto_Rx
    function_name: texto
    poll_rate: '4'
    value: '""'
  states: {}
- name: texto_rx
  id: variable_qtgui_label
  parameters:
    label: Texto recibido
    type: string
    value: texto_probe
  states: {}
- name: trama_bits
  id: variable
  parameters:
    comment: Preambulo 0x55555555 + SFD 0x904E + carga
    value: trama_telemetria.construir_trama(mensaje, pn9)
  states: {}
- name: update_every
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia VGA (dB)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: bits_rx
  id: qtgui_time_sink_x
  parameters:
    comment: Bits de la trama de telemetria
    grid: 'True'
    label1: Bits recuperados
    marker1: '0'
    name: '"Bits recuperados"'
    size: '32'
    srate: symbol_rate
    stemplot: 'True'
    type: float
    ylabel: Bit
    ymax: '1.2'
    ymin: '-0.2'
  states: {state: disabled}
- name: bits_to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: channel_filter
  id: low_pass_filter
  parameters:
    comment: |-
      Filtro de canal (parte del Rx digital), ajustado en la Fase 4:
      35 kHz / 10 kHz (antes 60/40): menos ruido al discriminador
    cutoff_freq: 35e3
    decim: '1'
    gain: '1.0'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: channel_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    grid: 'True'
    label1: Canal
    name: '"Canal FSK centrado (debe verse simetrico en fc)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {state: disabled}
- name: curva_ber
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: '"BER"'
    name: '"Curva BER experimental vs Eb/N0"'
    update_time: '0.2'
    vlen: N_EbN0
    width1: '3'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: EbN0_min
    x_step: EbN0_step
    x_units: '"dB"'
    y_axis_label: '"log10(BER)"'
    ymax: '0'
    ymin: '-7'
  states: {}
- name: data_filter
  id: blocks_moving_average_xx
  parameters:
    comment: Integrador (filtro acoplado NRZ), como en la Fase 2
    length: sps
    max_iter: '4000'
    scale: 1.0/sps
    type: float
  states: {}
- name: dc_blocker
  id: dc_blocker_xx
  parameters:
    comment: Quita el desplazamiento residual de frecuencia
    length: '3200'
    long_form: 'True'
    type: ff
  states: {}
- name: e_BER_CSV
  id: epy_block
  parameters:
    EbN0_max: EbN0_max
    EbN0_min: EbN0_min
    EbN0_step: EbN0_step
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from pathlib import Path
      import csv
      import time


      class blk(gr.sync_block):

          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=18.0,  # Ajuste Fase 4: GRC dimensiona los puertos con este valor (debe ser = EbN0_max)
                       EbN0_step=1.0,
                       nombre_archivo="curva_BER.csv",
                       guardar_cada=2.0):

              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)

              self.N = int(round(
                  (self.EbN0_max - self.EbN0_min) /
                  self.EbN0_step
              )) + 1

              gr.sync_block.__init__(
                  self,
                  name='Guardar curva BER en CSV',
                  in_sig=[
                      (np.float32, self.N),
                      (np.float32, self.N)
                  ],
                  out_sig=None
              )

              self.nombre_archivo = str(nombre_archivo)
              self.guardar_cada = float(guardar_cada)

              # El Embedded Python Block se genera junto al flowgraph de GNU Radio.
              # Por ello el CSV queda en la misma carpeta contenedora del .grc/.py.
              # Ajuste Fase 4: compatibilidad GNU Radio 3.10
              self.carpeta = Path(__file__).resolve().parent if '__file__' in globals() else Path.cwd()
              self.ruta_csv = self.carpeta / self.nombre_archivo

              self.ultimo_guardado = 0.0
              self.ebn0 = self.EbN0_min + self.EbN0_step * np.arange(self.N)

              print("CSV BER se guardará en:")
              print(self.ruta_csv)

          def guardar(self, ber, logber):
              archivo_temporal = self.ruta_csv.with_suffix(".tmp")

              with open(archivo_temporal, "w", newline="", encoding="utf-8") as f:
                  writer = csv.writer(f)
                  writer.writerow(["EbN0_dB", "BER", "log10_BER"])

                  for eb, b, lb in zip(self.ebn0, ber, logber):
                      writer.writerow([
                          f"{eb:.6f}",
                          f"{float(b):.12e}",
                          f"{float(lb):.12e}"
                      ])

              # Ajuste Fase 4: si otro programa tiene el CSV abierto (visor, Excel),
              # Windows impide reemplazarlo. Antes eso detenia el bloque y atascaba
              # el flujograma; ahora se reintenta en el siguiente guardado.
              try:
                  archivo_temporal.replace(self.ruta_csv)
              except OSError:
                  pass

          def work(self, input_items, output_items):
              ber_vectors = input_items[0]
              log_vectors = input_items[1]

              if len(ber_vectors) == 0:
                  return 0

              ahora = time.time()
              if ahora - self.ultimo_guardado >= self.guardar_cada:
                  try:
                      self.guardar(ber_vectors[-1], log_vectors[-1])
                  except OSError as e:  # Ajuste Fase 4: nunca detener el flujograma
                      print('[e_BER_CSV] no se pudo guardar (se reintenta):', e)
                  self.ultimo_guardado = ahora

              return len(ber_vectors)
    comment: |-
      Guarda la curva en Fase4/curva_BER.csv
      Cada corrida lo sobrescribe: renombrarlo al terminar (ascii / pn9)
    guardar_cada: '2.0'
    nombre_archivo: '"curva_BER.csv"'
  states: {}
- name: e_BER_Curve
  id: epy_block
  parameters:
    EbN0_max: EbN0_max
    EbN0_min: EbN0_min
    EbN0_step: EbN0_step
    _source_code: |
      """
      e_BER_Curve
      Acumulador de curva BER para los sistemas de los estudiantes.

      Entrada 0 : bits transmitidos de referencia (byte 0/1).
      Entrada 1 : bits recuperados por el receptor (byte 0/1).

      Salida 0  : vector BER lineal.
      Salida 1  : vector log10(BER) para QT GUI Vector Sink.

      El bloque usa exactamente el mismo barrido que e_EbN0_Sweep. Para cada punto:
      - ignora bits_guardia al comienzo del segmento;
      - compara bits_por_punto;
      - cuando el barrido vuelve a un punto, sigue acumulando estadísticas.

      delay_bits retrasa internamente la referencia Tx para compensar el retardo
      del receptor. Se ajusta primero en una condición limpia hasta lograr BER≈0.

      Cuando todavía no se observa ningún error, la salida logarítmica utiliza
      3/N como cota superior aproximada para poder mostrar el punto sin afirmar
      que BER=0.
      """

      import numpy as np
      import pmt
      from collections import deque
      from gnuradio import gr


      class blk(gr.decim_block):  # Ajuste Fase 4: compatibilidad GNU Radio 3.10
          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=18.0,  # Ajuste Fase 4: GRC dimensiona los puertos con este valor (debe ser = EbN0_max)
                       EbN0_step=1.0,
                       bits_por_punto=100000,
                       bits_guardia=1000,
                       delay_bits=0,
                       update_every=1000,
                       segmentos_arranque=3,  # Ajuste Fase 4: descartar el arranque
                       descartar_antes=8000,  # Ajuste Fase 4 v2: bits previos a un realineo
                       descartar_despues=1000):  # Ajuste Fase 4 v2: bits posteriores
              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)
              self.bits_por_punto = max(1, int(bits_por_punto))
              self.bits_guardia = max(0, int(bits_guardia))
              self.delay_bits = max(0, int(delay_bits))
              self.update_every = max(1, int(update_every))
              # Ajuste Fase 4 (hardware): no contar los primeros segmentos de la PRIMERA
              # pasada (overflows al abrir la GUI y alineacion de la referencia). La
              # asignacion de puntos no cambia; esos puntos se miden en pasadas siguientes.
              self.segmentos_arranque = max(0, int(segmentos_arranque))
              # Ajuste Fase 4 v2 (hardware): si se pierden muestras (overflow del HackRF,
              # underrun del USRP) la referencia se desalinea hasta que e_Ref_Alineada lo
              # detecta y emite el tag 'realineo'. Los bits comparados en ese lapso no son
              # errores del receptor: se retienen descartar_antes bits sin contar y, ante
              # un tag, se descartan junto con los descartar_despues siguientes.
              self.descartar_antes = max(0, int(descartar_antes))
              self.descartar_despues = max(0, int(descartar_despues))
              self.pendientes = deque()   # (point_index, error) aun sin contar
              self.saltar_hasta = -1      # indice absoluto hasta el que se ignoran bits
              self.descartados = 0
              self.realineos = 0
              self.contados = 0

              if self.EbN0_step <= 0:
                  raise ValueError("EbN0_step debe ser > 0")
              if self.EbN0_max < self.EbN0_min:
                  raise ValueError("EbN0_max debe ser >= EbN0_min")

              npts = int(round((self.EbN0_max-self.EbN0_min)/self.EbN0_step)) + 1
              self.eb_axis = self.EbN0_min + self.EbN0_step*np.arange(npts, dtype=np.float64)
              self.N = len(self.eb_axis)
              self.segment_bits = self.bits_guardia + self.bits_por_punto

              # Ajuste Fase 4: compatibilidad GNU Radio 3.10
              gr.decim_block.__init__(
                  self,
                  name='e_BER_Curve',
                  in_sig=[np.int8, np.int8],
                  out_sig=[(np.float32, self.N), (np.float32, self.N)],
                  decim=self.update_every
              )

              self.tx_fifo = deque([0]*self.delay_bits)
              self.raw_items = 0
              self.valid_bit_index = 0

              self.count = np.zeros(self.N, dtype=np.int64)
              self.errors = np.zeros(self.N, dtype=np.int64)
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def _realineo(self, abs_idx):
              n = len(self.pendientes)
              self.pendientes.clear()
              self.saltar_hasta = abs_idx + self.descartar_despues
              self.descartados += n + self.descartar_despues
              self.realineos += 1
              total = self.descartados + self.contados
              print('[e_BER_Curve] realineo #%d: %d bits descartados (acumulado %.2f %% de los bits)'
                    % (self.realineos, n + self.descartar_despues,
                       100.0 * self.descartados / max(1, total)))

          def _contar(self, point_index, error):
              self.pendientes.append((point_index, error))
              while len(self.pendientes) > self.descartar_antes:
                  p, e = self.pendientes.popleft()
                  self.count[p] += 1
                  self.errors[p] += e
                  self.contados += 1

          def _process(self, tx, rx, abs0=0, marcas=()):
              for k, (t, r) in enumerate(zip(tx, rx)):
                  abs_idx = abs0 + k
                  if abs_idx in marcas:
                      self._realineo(abs_idx)
                  tb = int(t) & 1
                  rb = int(r) & 1

                  if self.delay_bits > 0:
                      self.tx_fifo.append(tb)
                      t_aligned = self.tx_fifo.popleft()
                      if self.raw_items < self.delay_bits:
                          self.raw_items += 1
                          continue
                  else:
                      t_aligned = tb

                  bit_index = self.valid_bit_index
                  segment_index = bit_index // self.segment_bits
                  point_index = segment_index % self.N
                  pos = bit_index % self.segment_bits

                  # Dejar que filtros/sincronizadores se estabilicen después
                  # del cambio de nivel de ruido.
                  if (pos >= self.bits_guardia and segment_index >= self.segmentos_arranque
                          and abs_idx > self.saltar_hasta):
                      self._contar(point_index, 1 if t_aligned != rb else 0)

                  self.valid_bit_index += 1
                  self.raw_items += 1

          def _vectors(self):
              ber = np.zeros(self.N, dtype=np.float32)
              logber = np.zeros(self.N, dtype=np.float32)

              for i in range(self.N):
                  n = int(self.count[i])
                  e = int(self.errors[i])

                  if n <= 0:
                      ber[i] = 0.0
                      logber[i] = 0.0
                  elif e > 0:
                      b = e/float(n)
                      ber[i] = b
                      logber[i] = np.log10(max(b, 1e-12))
                  else:
                      # BER observado = 0; para la gráfica usamos una cota superior.
                      ber[i] = 0.0
                      upper = min(1.0, 3.0/float(n))
                      logber[i] = np.log10(max(upper, 1e-12))

              return ber, logber

          def work(self, input_items, output_items):
              tx = input_items[0]
              rx = input_items[1]
              out_ber = output_items[0]
              out_log = output_items[1]

              nout = len(out_ber)
              D = self.update_every
              base = self.nitems_read(0)
              marcas = set(t.offset for t in self.get_tags_in_window(
                  0, 0, min(len(tx), nout * D), pmt.intern('realineo')))

              for k in range(nout):
                  a = k*D
                  b = min((k+1)*D, len(tx))
                  if a < b:
                      self._process(tx[a:b], rx[a:b], base + a, marcas)

                  ber, logber = self._vectors()
                  out_ber[k, :] = ber
                  out_log[k, :] = logber

              return nout
    bits_guardia: bits_guardia
    bits_por_punto: bits_por_punto
    comment: |-
      Entrada 0: bits Tx de referencia
      Entrada 1: bits Rx (slicer)
    delay_bits: delay_bits
    descartar_antes: '8000'
    descartar_despues: '1000'
    segmentos_arranque: '3'
    update_every: update_every
  states: {}
- name: e_EbN0_Sweep
  id: epy_block
  parameters:
    EbN0_max: EbN0_max
    EbN0_min: EbN0_min
    EbN0_step: EbN0_step
    _source_code: |
      """
      e_EbN0_Sweep
      Instrumento para caracterización BER con un enlace SDR ya funcional.

      Entrada 0 : señal compleja I/Q recibida del SDR (preferiblemente DESPUÉS
                  de la adaptación radio_rate -> bb_rate).
      Salida 0  : la misma señal I/Q con AWGN adicional controlado.
      Salida 1  : valor instantáneo de Eb/N0 [dB] usado en el barrido.

      El bloque NO sustituye el USRP/HackRF ni el receptor. Se inserta entre
      la salida I/Q del SDR y la entrada del receptor digital.

      El barrido se hace por segmentos contiguos. Cada punto se mantiene durante:
          bits_guardia + bits_por_punto

      La potencia de ruido artificial se calcula a partir de la potencia promedio
      medida ANTES de agregar el ruido:

          Eb = Ps / Rb
          N0 = Eb / (Eb/N0)
          Pn = N0 * Fs

      por lo tanto:

          Pn = Ps * Fs / (Rb * 10**(EbN0_dB/10))

      El ruido complejo se genera con varianza total Pn.
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       samp_rate=256000.0,
                       bit_rate=64000.0,
                       bits_por_punto=100000,
                       bits_guardia=1000,
                       signal_power=0.0,
                       seed=2026):
              gr.sync_block.__init__(
                  self,
                  name='e_EbN0_Sweep',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.float32]
              )

              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)
              self.samp_rate = float(samp_rate)
              self.bit_rate = float(bit_rate)
              self.bits_por_punto = max(1, int(bits_por_punto))
              self.bits_guardia = max(0, int(bits_guardia))
              self.signal_power_cfg = float(signal_power)

              if self.EbN0_step <= 0:
                  raise ValueError("EbN0_step debe ser > 0")
              if self.samp_rate <= 0 or self.bit_rate <= 0:
                  raise ValueError("samp_rate y bit_rate deben ser > 0")
              if self.EbN0_max < self.EbN0_min:
                  raise ValueError("EbN0_max debe ser >= EbN0_min")

              npts = int(round((self.EbN0_max-self.EbN0_min)/self.EbN0_step)) + 1
              self.eb_axis = self.EbN0_min + self.EbN0_step*np.arange(npts, dtype=np.float64)
              self.segment_bits = self.bits_guardia + self.bits_por_punto

              self.sample_count = 0
              self.power_sum = 0.0
              self.power_count = 0
              self.rng = np.random.default_rng(int(seed))

          def _signal_power(self, x):
              if self.signal_power_cfg > 0:
                  return self.signal_power_cfg

              # Promedio acumulado de la señal recibida ANTES del ruido artificial.
              self.power_sum += float(np.sum(np.abs(x.astype(np.complex128))**2))
              self.power_count += len(x)
              if self.power_count <= 0:
                  return 0.0
              return max(self.power_sum/self.power_count, 1e-20)

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              eb_out = output_items[1]
              n = len(x)
              if n == 0:
                  return 0

              Ps = self._signal_power(x)

              # Índice absoluto de muestra -> índice equivalente de bit.
              s = self.sample_count + np.arange(n, dtype=np.float64)
              bit_index = np.floor(s*self.bit_rate/self.samp_rate).astype(np.int64)

              segment_index = bit_index // self.segment_bits
              point_index = np.mod(segment_index, len(self.eb_axis))
              ebn0_db = self.eb_axis[point_index]
              ebn0_lin = np.power(10.0, ebn0_db/10.0)

              # Potencia total del ruido complejo por muestra.
              noise_power = Ps*self.samp_rate/(self.bit_rate*ebn0_lin)
              sigma_iq = np.sqrt(np.maximum(noise_power, 0.0)/2.0)

              noise = (
                  self.rng.standard_normal(n)*sigma_iq
                  + 1j*self.rng.standard_normal(n)*sigma_iq
              ).astype(np.complex64)

              y[:] = x + noise
              eb_out[:] = ebn0_db.astype(np.float32)

              self.sample_count += n
              return n
    bit_rate: Rb
    bits_guardia: bits_guardia
    bits_por_punto: bits_por_punto
    comment: 'Instrumento: AWGN controlado (barrido de Eb/N0)'
    samp_rate: bb_rate
    seed: '2026'
    signal_power: '0.0'
  states: {}
- name: e_Ref_Alineada
  id: epy_block
  parameters:
    _source_code: |
      """
      e_Ref_Alineada
      Genera la referencia Tx (la trama de telemetria repetida) ALINEADA con los bits
      recuperados, para que e_BER_Curve trabaje con delay_bits = 0.

      Se usa porque el Tx y el Rx corren en computadores distintos: el desfase entre
      la trama recibida y una referencia local cambia en cada ejecucion, y la deriva
      de reloj puede desplazarlo durante la medicion.

      Entrada 0 : bits recuperados por el receptor (byte 0/1).
      Salida 0  : bit de referencia correspondiente a cada bit recibido (byte 0/1).

      Metodo: correlacion circular de los bits recibidos (+-1) con la trama conocida,
      acumulada hasta que el pico es estadisticamente claro (z >= z_min). Entonces se
      fija el desfase. Ya alineada, corrige cualquier salto (busqueda global; Ajuste
      Fase 4) con la misma exigencia estadistica. max_salto ya no se usa. Funciona aun con BER alta: a menor
      Eb/N0 solo tarda mas en decidir. La referencia NO copia bits del receptor:
      siempre es la trama conocida, desplazada el desfase elegido.
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, trama=(0, 1), z_min=10.0, max_salto=3, min_bits=2000, max_bits=20000):
              gr.sync_block.__init__(
                  self,
                  name='e_Ref_Alineada',
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )
              self.trama = np.array(trama, dtype=np.int8) & 1
              self.L = len(self.trama)
              self.t_pm = 2.0 * self.trama - 1.0
              self.T_fft = np.conj(np.fft.fft(self.t_pm))
              self.z_min = float(z_min)
              self.max_salto = int(max_salto)
              self.min_bits = int(min_bits)
              self.max_bits = int(max_bits)

              self.n = 0                  # indice absoluto del proximo bit recibido
              self.desfase = None         # d: ref[n] = trama[(n - d) % L]
              self.acc = np.zeros(self.L)
              self.acc_bits = 0
              self.cambios = 0
              self.marcar = False   # Ajuste Fase 4 v2: avisar a e_BER_Curve
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def _decidir(self):
              # c[d] = sum_n rx_pm[n] * t_pm[(n - d) % L]
              c = np.real(np.fft.ifft(np.fft.fft(self.acc) * self.T_fft))
              sigma = np.sqrt(self.acc_bits)  # desviacion de c[d] para un desfase incorrecto
              if self.desfase is None:
                  d = int(np.argmax(c))
                  if c[d] / sigma < self.z_min:
                      return
              else:
                  # Ajuste Fase 4 (hardware): realineacion GLOBAL. Un overflow del HackRF o un
                  # underrun del USRP puede saltar mas de +-max_salto bits; antes el bloque
                  # quedaba desalineado para siempre (BER ~0.4 con el texto llegando bien).
                  # Ahora se busca en todos los desfases, con la misma exigencia (z >= z_min).
                  d = int(np.argmax(c))
                  if d == self.desfase:
                      # Desfase actual confirmado: reiniciar la ventana para detectar
                      # rapido un salto futuro. Si aun no hay evidencia, seguir acumulando.
                      if c[d] / sigma >= self.z_min or self.acc_bits >= self.max_bits:
                          self.acc[:] = 0.0
                          self.acc_bits = 0
                      return
                  if (c[d] - c[self.desfase]) / sigma < self.z_min:
                      # Sin evidencia suficiente: seguir acumulando (hasta max_bits)
                      if self.acc_bits >= self.max_bits:
                          self.acc[:] = 0.0
                          self.acc_bits = 0
                      return
              z = c[d] / sigma
              if d != self.desfase:
                  if self.desfase is not None:
                      self.cambios += 1
                      print('[e_Ref_Alineada] desfase corregido: %d -> %d bits (z = %.1f)'
                            % (self.desfase, d, z))
                  else:
                      print('[e_Ref_Alineada] alineada: desfase = %d bits (z = %.1f, %d bits)'
                            % (d, z, self.acc_bits))
                  self.desfase = d
                  self.marcar = True
              self.acc[:] = 0.0
              self.acc_bits = 0

          def work(self, input_items, output_items):
              rx = input_items[0]
              out = output_items[0]
              m = len(rx)
              idx = self.n + np.arange(m)

              d = 0 if self.desfase is None else self.desfase
              out[:] = self.trama[(idx - d) % self.L]

              np.add.at(self.acc, idx % self.L, 2.0 * (rx & 1) - 1.0)
              self.acc_bits += m
              self.n += m
              # Antes de alinearse se evalua seguido (cada 250 bits) para fijar el desfase
              # dentro de los bits de guarda del primer punto; despues, cada min_bits.
              if self.acc_bits >= (250 if self.desfase is None else self.min_bits):
                  self._decidir()
              if self.marcar:
                  # Ajuste Fase 4 v2: los bits anteriores a este punto se compararon con
                  # una referencia desalineada; e_BER_Curve los descarta.
                  self.add_item_tag(0, self.nitems_written(0) + m - 1,
                                    pmt.intern('realineo'), pmt.from_long(self.desfase))
                  self.marcar = False
              return m
    comment: |-
      Referencia Tx (trama conocida) alineada automaticamente
      con los bits recibidos (Tx y Rx en PCs distintos)
    max_bits: '20000'
    max_salto: '3'
    min_bits: '2000'
    trama: trama_bits
    z_min: '10.0'
  states: {}
- name: e_Texto_Rx
  id: epy_block
  parameters:
    _source_code: |
      """
      e_Texto_Rx
      Rama de verificacion visual: reconstruye el texto de telemetria a partir de
      los bits recuperados. NO interviene en la medicion BER.

      Entrada 0 : bits recuperados por el receptor (byte 0/1, salida del Binary Slicer).

      Busca la palabra de sincronizacion (ultimos 16 bits del preambulo + SFD 0x904E),
      toma los bits de la carga, quita el blanqueo PN9 si pn9 = 1, y compara el texto
      con el mensaje esperado.

      Metodos para Function Probe:
          texto()  -> ultimo texto recibido
          estado() -> contador de tramas correctas / con error
      """

      import time

      import numpy as np
      from gnuradio import gr

      SINCRONIA = 0x5555904E      # 0x5555 (fin del preambulo) + SFD 0x904E
      SINCRONIA_BITS = 32
      MASCARA = (1 << SINCRONIA_BITS) - 1


      class blk(gr.sync_block):
          def __init__(self, mensaje="ID:S01", pn9=0, max_errores_sincronia=2,
                       imprimir_cada=1.0):
              gr.sync_block.__init__(
                  self,
                  name='e_Texto_Rx',
                  in_sig=[np.int8],
                  out_sig=None
              )
              self.mensaje = str(mensaje)
              self.pn9 = int(pn9)
              self.max_errores_sincronia = int(max_errores_sincronia)
              self.imprimir_cada = float(imprimir_cada)

              self.carga_esperada = self._bytes_a_bits(self.mensaje.encode('ascii', errors='replace'))
              if self.pn9:
                  self.carga_esperada = self._blanquear(self.carga_esperada)
              self.n_carga = len(self.carga_esperada)

              self.registro = 0
              self.capturando = False
              self.carga = []

              self.tramas_ok = 0
              self.tramas_error = 0
              self.ultimo_texto = '(esperando trama...)'
              self.ultimo_errores = 0
              self.ultima_impresion = 0.0

          @staticmethod
          def _bytes_a_bits(datos):
              return [(b >> (7 - i)) & 1 for b in datos for i in range(8)]

          @staticmethod
          def _blanquear(bits):
              # PN9: x^9 + x^5 + 1, semilla 0x1FF (igual que trama_telemetria)
              estado = 0x1FF
              salida = []
              for b in bits:
                  salida.append(b ^ (estado & 1))
                  nuevo = (estado ^ (estado >> 5)) & 1
                  estado = (estado >> 1) | (nuevo << 8)
              return salida

          @staticmethod
          def _visible(datos):
              return ''.join(chr(c) if 32 <= c < 127 else '?' for c in datos)

          def _cerrar_trama(self):
              errores = sum(a != b for a, b in zip(self.carga, self.carga_esperada))
              bits = self._blanquear(self.carga) if self.pn9 else self.carga
              datos = bytes(
                  sum(bits[k + i] << (7 - i) for i in range(8))
                  for k in range(0, len(bits) - 7, 8)
              )
              self.ultimo_texto = self._visible(datos)
              self.ultimo_errores = errores
              if errores == 0:
                  self.tramas_ok += 1
              else:
                  self.tramas_error += 1

              ahora = time.time()
              if ahora - self.ultima_impresion >= self.imprimir_cada:
                  self.ultima_impresion = ahora
                  print('[Rx] %s | %s' % (self.ultimo_texto, self.estado()))

          def texto(self):
              return self.ultimo_texto

          def estado(self):
              total = self.tramas_ok + self.tramas_error
              return 'Tramas OK: %d / %d | errores en la ultima: %d bits' % (
                  self.tramas_ok, total, self.ultimo_errores)

          def work(self, input_items, output_items):
              for b in input_items[0]:
                  bit = int(b) & 1
                  if self.capturando:
                      self.carga.append(bit)
                      if len(self.carga) == self.n_carga:
                          self._cerrar_trama()
                          self.capturando = False
                          self.registro = 0
                      continue

                  self.registro = ((self.registro << 1) | bit) & MASCARA
                  if bin(self.registro ^ SINCRONIA).count('1') <= self.max_errores_sincronia:
                      self.capturando = True
                      self.carga = []
              return len(input_items[0])
    comment: Verificacion visual del texto (no afecta la BER)
    imprimir_cada: '1.0'
    max_errores_sincronia: '2'
    mensaje: mensaje
    pn9: pn9
  states: {}
- name: ebn0_actual
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"Eb/N0 aplicado"'
    max: EbN0_max
    min: EbN0_min
    name: '"Punto actual del barrido"'
    type: float
    unit1: '"dB"'
    update_time: '0.25'
  states: {}
- name: eye_rx
  id: qtgui_eye_sink_x
  parameters:
    comment: Ojo a la salida del integrador (maxima apertura al final de cada simbolo)
    label1: Salida filtrada
    samp_per_symbol: sps
    size: '2000'
    srate: samp_rate
    type: float
    ylabel: Amplitud
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: freq_inst
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Demodulada
    name: '"Frecuencia instantanea filtrada"'
    size: '2000'
    srate: samp_rate
    type: float
    ylabel: Amplitud
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: fsk_demod
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Frecuencia instantanea normalizada
      (+1 = bit 1, -1 = bit 0)
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: vga_gain
    comment: |-
      HackRF: RF Gain = amplificador (0 o 14 dB),
      IF Gain = LNA, BB Gain = VGA
    freq0: fc - lo_offset
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: lna_gain
    sample_rate: hackrf_rate
    sync: none
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iq_const
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: 'Envolvente constante: circulo; el ruido engrosa el anillo'
    grid: 'True'
    label1: I-Q
    name: '"Plano I-Q de la señal filtrada (FSK = círculo)"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: rate_adapt
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo_offset + freq_corr
    comment: |-
      Adaptacion de tasa: centra la senal y baja de 8 MS/s a 1 MS/s
      con un filtro ANCHO (300 kHz), para que el filtro de canal
      quede despues del ruido de e_EbN0_Sweep
    decim: decim
    samp_rate: hackrf_rate
    taps: firdes.low_pass(1.0, hackrf_rate, 300e3, 100e3)
    type: ccc
  states: {}
- name: raw_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: hackrf_rate
    fc: fc - lo_offset
    fftsize: '4096'
    grid: 'True'
    label1: HackRF
    name: '"Espectro recibido (HackRF, 8 MS/s)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {state: disabled}
- name: slicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: symbol_sync
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Recupera el reloj del Tx (sigue la deriva) y elige
      el instante de muestreo. Reemplaza Delay + Keep 1 in N
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.05'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: trama_telemetria
  id: epy_module
  parameters:
    comment: Arma la trama. El mismo modulo va en el receptor.
    source_code: |
      """
      trama_telemetria
      Arma la trama de telemetria de la Fase 4 (formato tipo IEEE 802.15.4g SUN-FSK):

          [preambulo 32 bits 0x55555555][SFD 16 bits 0x904E][carga: mensaje ASCII, MSB primero]

      Si pn9 = 1, la carga se blanquea con la secuencia PN9 (x^9 + x^5 + 1, semilla 0x1FF).
      El preambulo y el SFD nunca se blanquean, para poder detectarlos en el receptor.

      El mismo modulo va en el transmisor y en el receptor, para que ambos tengan
      exactamente la misma secuencia de referencia.
      """

      PREAMBULO = 0x55555555
      PREAMBULO_BITS = 32
      SFD = 0x904E
      SFD_BITS = 16


      def entero_a_bits(valor, n):
          """Entero -> lista de n bits, MSB primero."""
          return [(valor >> (n - 1 - i)) & 1 for i in range(n)]


      def bytes_a_bits(datos):
          """Bytes -> lista de bits, MSB primero en cada byte."""
          return [(b >> (7 - i)) & 1 for b in datos for i in range(8)]


      def bits_a_bytes(bits):
          """Lista de bits (MSB primero) -> bytes. Ignora los bits sobrantes."""
          datos = bytearray()
          for k in range(0, len(bits) - 7, 8):
              b = 0
              for bit in bits[k:k + 8]:
                  b = (b << 1) | (int(bit) & 1)
              datos.append(b)
          return bytes(datos)


      def secuencia_pn9(n):
          """n bits de la PN9 (x^9 + x^5 + 1) con semilla 0x1FF."""
          estado = 0x1FF
          salida = []
          for _ in range(n):
              salida.append(estado & 1)
              nuevo = (estado ^ (estado >> 5)) & 1
              estado = (estado >> 1) | (nuevo << 8)
          return salida


      def blanquear(bits):
          """XOR con la PN9. Aplicarlo dos veces devuelve los bits originales."""
          return [b ^ p for b, p in zip(bits, secuencia_pn9(len(bits)))]


      def carga_bits(mensaje, pn9=0):
          """Bits de la carga (mensaje ASCII), blanqueados si pn9 = 1."""
          bits = bytes_a_bits(str(mensaje).encode('ascii', errors='replace'))
          return blanquear(bits) if int(pn9) else bits


      def construir_trama(mensaje, pn9=0):
          """Trama completa como lista de bits 0/1."""
          return (entero_a_bits(PREAMBULO, PREAMBULO_BITS)
                  + entero_a_bits(SFD, SFD_BITS)
                  + carga_bits(mensaje, pn9))


      def decodificar_carga(bits, pn9=0):
          """Bits de carga recibidos -> texto (para el receptor)."""
          bits = [int(b) & 1 for b in bits]
          if int(pn9):
              bits = blanquear(bits)
          return bits_a_bytes(bits).decode('ascii', errors='replace')
  states: {}

connections:
- [bits_to_float, '0', bits_rx, '0']
- [channel_filter, '0', channel_spectrum, '0']
- [channel_filter, '0', fsk_demod, '0']
- [channel_filter, '0', iq_const, '0']
- [data_filter, '0', eye_rx, '0']
- [data_filter, '0', freq_inst, '0']
- [data_filter, '0', symbol_sync, '0']
- [dc_blocker, '0', data_filter, '0']
- [e_BER_Curve, '0', e_BER_CSV, '0']
- [e_BER_Curve, '1', curva_ber, '0']
- [e_BER_Curve, '1', e_BER_CSV, '1']
- [e_EbN0_Sweep, '0', channel_filter, '0']
- [e_EbN0_Sweep, '1', ebn0_actual, '0']
- [e_Ref_Alineada, '0', e_BER_Curve, '0']
- [fsk_demod, '0', dc_blocker, '0']
- [hackrf_source, '0', rate_adapt, '0']
- [hackrf_source, '0', raw_spectrum, '0']
- [rate_adapt, '0', e_EbN0_Sweep, '0']
- [slicer, '0', bits_to_float, '0']
- [slicer, '0', e_BER_Curve, '1']
- [slicer, '0', e_Ref_Alineada, '0']
- [slicer, '0', e_Texto_Rx, '0']
- [symbol_sync, '0', slicer, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
