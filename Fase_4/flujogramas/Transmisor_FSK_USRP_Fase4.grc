options:
  parameters:
    comment: 'Fase 4: transmite en bucle una trama de telemetria fija (preambulo + SFD + mensaje)'
    description: Transmisor FSK binario por USRP 2920 con trama de telemetria conocida para medir BER
    generate_options: qt_gui
    id: Transmisor_FSK_USRP_Fase4
    output_language: python
    title: 'Transmisor FSK - USRP 2920 (Fase 4: trama de telemetria)'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Misma tasa para el modulador y el USRP
      (100 MHz / 100 = 1 MS/s, valida en el 2920)
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por simbolo
    value: '100'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Frecuencia portadora
    value: 870e6
  states: {}
- name: fsk_deviation
  id: variable_qtgui_range
  parameters:
    label: Desviación FSK (Hz)
    start: '5000'
    step: '1000'
    stop: '100000'
    value: '20000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'Ganancia TX del 2920 (WBX): 0 a 31.5 dB'
    label: Ganancia TX (dB)
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: Amplitud digital (<1 para no saturar el DAC)
    label: Amplitud
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.7'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: trama_telemetria
  id: epy_module
  parameters:
    comment: Arma la trama. El mismo modulo va en el receptor.
    source_code: |
      """
      trama_telemetria
      Arma la trama de telemetria de la Fase 4 (formato tipo IEEE 802.15.4g SUN-FSK):

          [preambulo 32 bits 0x55555555][SFD 16 bits 0x904E][carga: mensaje ASCII, MSB primero]

      Si pn9 = 1, la carga se blanquea con la secuencia PN9 (x^9 + x^5 + 1, semilla 0x1FF).
      El preambulo y el SFD nunca se blanquean, para poder detectarlos en el receptor.

      El mismo modulo va en el transmisor y en el receptor, para que ambos tengan
      exactamente la misma secuencia de referencia.
      """

      PREAMBULO = 0x55555555
      PREAMBULO_BITS = 32
      SFD = 0x904E
      SFD_BITS = 16


      def entero_a_bits(valor, n):
          """Entero -> lista de n bits, MSB primero."""
          return [(valor >> (n - 1 - i)) & 1 for i in range(n)]


      def bytes_a_bits(datos):
          """Bytes -> lista de bits, MSB primero en cada byte."""
          return [(b >> (7 - i)) & 1 for b in datos for i in range(8)]


      def bits_a_bytes(bits):
          """Lista de bits (MSB primero) -> bytes. Ignora los bits sobrantes."""
          datos = bytearray()
          for k in range(0, len(bits) - 7, 8):
              b = 0
              for bit in bits[k:k + 8]:
                  b = (b << 1) | (int(bit) & 1)
              datos.append(b)
          return bytes(datos)


      def secuencia_pn9(n):
          """n bits de la PN9 (x^9 + x^5 + 1) con semilla 0x1FF."""
          estado = 0x1FF
          salida = []
          for _ in range(n):
              salida.append(estado & 1)
              nuevo = (estado ^ (estado >> 5)) & 1
              estado = (estado >> 1) | (nuevo << 8)
          return salida


      def blanquear(bits):
          """XOR con la PN9. Aplicarlo dos veces devuelve los bits originales."""
          return [b ^ p for b, p in zip(bits, secuencia_pn9(len(bits)))]


      def carga_bits(mensaje, pn9=0):
          """Bits de la carga (mensaje ASCII), blanqueados si pn9 = 1."""
          bits = bytes_a_bits(str(mensaje).encode('ascii', errors='replace'))
          return blanquear(bits) if int(pn9) else bits


      def construir_trama(mensaje, pn9=0):
          """Trama completa como lista de bits 0/1."""
          return (entero_a_bits(PREAMBULO, PREAMBULO_BITS)
                  + entero_a_bits(SFD, SFD_BITS)
                  + carga_bits(mensaje, pn9))


      def decodificar_carga(bits, pn9=0):
          """Bits de carga recibidos -> texto (para el receptor)."""
          bits = [int(b) & 1 for b in bits]
          if int(pn9):
              bits = blanquear(bits)
          return bits_a_bytes(bits).decode('ascii', errors='replace')
  states: {}
- name: mensaje
  id: variable
  parameters:
    comment: 'Lecturas simuladas FIJAS: el receptor debe conocer el mismo texto'
    value: '"ID:S01;T:24.5C;HR:15%;ALT:2500msnm;P:184kPa;NIV:72%;Q:3.4m3/h"'
  states: {}
- name: pn9
  id: variable
  parameters:
    comment: |-
      0 = carga ASCII sin blanqueo
      1 = carga blanqueada con PN9
      Debe valer lo mismo en el Tx y en el Rx
    value: '0'
  states: {}
- name: trama_bits
  id: variable
  parameters:
    comment: Preambulo 0x55555555 + SFD 0x904E + carga
    value: trama_telemetria.construir_trama(mensaje, pn9)
  states: {}
- name: bit_source
  id: blocks_vector_source_x
  parameters:
    comment: Trama de telemetria repetida en bucle
    repeat: 'True'
    type: byte
    vector: trama_bits
  states: {}
- name: nrz_mapper
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      bit 0 -> -1 (fc - desviacion)
      bit 1 -> +1 (fc + desviacion)
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: symbol_repeat
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: fsk_modulator
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*fsk_deviation/samp_rate
  states: {}
- name: amp_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    comment: 'USRP 2920: sin GPSDO -> Sync = none'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: tx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    grid: 'True'
    label1: Tx
    name: '"Espectro FSK transmitido"'
    type: complex
  states: {}

connections:
- [bit_source, '0', nrz_mapper, '0']
- [nrz_mapper, '0', symbol_repeat, '0']
- [symbol_repeat, '0', fsk_modulator, '0']
- [fsk_modulator, '0', amp_scale, '0']
- [amp_scale, '0', uhd_usrp_sink_0, '0']
- [amp_scale, '0', tx_spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
