options:
  parameters:
    comment: 'Receptor FSK con HackRF One (Tx: USRP 2920)'
    description: Receptor FSK binario con HackRF One
    generate_options: qt_gui
    id: Receptor_FSK_HackRF_Ojo
    output_language: python
    title: Receptor FSK - HackRF One (con diagrama de ojo)
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Debe ser igual a la del transmisor
    value: 870e6
  states: {}
- name: freq_corr
  id: variable_qtgui_range
  parameters:
    comment: |-
      Corrige el error de cristal entre
      USRP y HackRF (puede ser de varios kHz)
    label: Corrección de frecuencia (Hz)
    start: '-40000'
    step: '100'
    stop: '40000'
    value: '0'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    comment: Igual al transmisor
    value: 20e3
  states: {}
- name: hackrf_rate
  id: variable
  parameters:
    comment: Tasa del HackRF (minimo 2 MS/s)
    value: 8e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia LNA (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: lo_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      El HackRF se sintoniza lo_offset abajo de fc.
      Deslizar para alejar su pico de DC de la senal
    label: Desplazamiento del pico DC del HackRF (Hz)
    start: '0'
    step: '10000'
    stop: '2000000'
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Igual a la del transmisor (1 MS/s)
    value: hackrf_rate/decim
  states: {}
- name: sample_delay
  id: variable_qtgui_range
  parameters:
    comment: |-
      Ajustar hasta que los bits se vean limpios
      (muestrear en el centro del simbolo)
    label: Retardo de muestreo (muestras)
    rangeType: int
    start: '0'
    step: '1'
    stop: sps-1
    value: '50'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Igual al transmisor
    value: '100'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia VGA (dB)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: bits_rx
  id: qtgui_time_sink_x
  parameters:
    comment: 'Patron Tx: 0,1,0,0,1,1,0,1,1,1,0,0,1,0,1,0'
    grid: 'True'
    label1: Bits recuperados
    marker1: '0'
    name: '"Bits recuperados"'
    size: '32'
    srate: symbol_rate
    stemplot: 'True'
    type: float
    ylabel: Bit
    ymax: '1.2'
    ymin: '-0.2'
  states: {}
- name: bits_to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: channel_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo_offset + freq_corr
    comment: |-
      Centra la senal FSK, filtra
      y baja de 8 MS/s a 1 MS/s
    decim: decim
    samp_rate: hackrf_rate
    taps: firdes.low_pass(1.0, hackrf_rate, 60e3, 40e3)
    type: ccc
  states: {}
- name: channel_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    grid: 'True'
    label1: Canal
    name: '"Canal FSK centrado (debe verse simetrico en fc)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: data_filter
  id: low_pass_filter
  parameters:
    cutoff_freq: symbol_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: symbol_rate/2
    win: window.WIN_HAMMING
  states: {}
- name: dc_blocker
  id: dc_blocker_xx
  parameters:
    comment: Quita el desplazamiento residual de frecuencia
    length: '3200'
    long_form: 'True'
    type: ff
  states: {}
- name: eye_rx
  id: qtgui_eye_sink_x
  parameters:
    comment: Ajustar sample_delay hasta que la maxima apertura quede en el centro
    label1: Salida filtrada
    samp_per_symbol: sps
    size: '2000'
    srate: samp_rate
    type: float
    ylabel: Amplitud
    ymax: '2'
    ymin: '-2'
  states: {}
- name: freq_inst
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Demodulada
    name: '"Frecuencia instantanea filtrada"'
    size: '2000'
    srate: samp_rate
    type: float
    ylabel: Amplitud
    ymax: '2'
    ymin: '-2'
  states: {}
- name: fsk_demod
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Frecuencia instantanea normalizada
      (+1 = bit 1, -1 = bit 0)
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: vga_gain
    comment: |-
      HackRF: RF Gain = amplificador (0 o 14 dB),
      IF Gain = LNA, BB Gain = VGA
    freq0: fc - lo_offset
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: lna_gain
    sample_rate: hackrf_rate
    sync: none
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iq_const
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: 'Envolvente constante: circulo; el ruido engrosa el anillo'
    grid: 'True'
    label1: I-Q
    name: '"Plano I-Q de la señal filtrada (FSK = círculo)"'
    size: '1024'
    type: complex
  states: {}
- name: raw_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: hackrf_rate
    fc: fc - lo_offset
    fftsize: '4096'
    grid: 'True'
    label1: HackRF
    name: '"Espectro recibido (HackRF, 8 MS/s)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: sample_align
  id: blocks_delay
  parameters:
    delay: sample_delay
    type: float
  states: {}
- name: slicer
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: symbol_sampler
  id: blocks_keep_one_in_n
  parameters:
    comment: Una muestra por simbolo
    n: sps
    type: float
  states: {}

connections:
- [bits_to_float, '0', bits_rx, '0']
- [channel_filter, '0', channel_spectrum, '0']
- [channel_filter, '0', fsk_demod, '0']
- [channel_filter, '0', iq_const, '0']
- [data_filter, '0', freq_inst, '0']
- [data_filter, '0', sample_align, '0']
- [dc_blocker, '0', data_filter, '0']
- [fsk_demod, '0', dc_blocker, '0']
- [hackrf_source, '0', channel_filter, '0']
- [hackrf_source, '0', raw_spectrum, '0']
- [sample_align, '0', eye_rx, '0']
- [sample_align, '0', symbol_sampler, '0']
- [slicer, '0', bits_to_float, '0']
- [symbol_sampler, '0', slicer, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
