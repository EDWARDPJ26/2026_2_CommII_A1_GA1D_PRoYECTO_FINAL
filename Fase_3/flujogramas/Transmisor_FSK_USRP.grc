options:
  parameters:
    comment: Transmisor FSK con USRP 2920 (recepcion con HackRF One)
    description: Transmisor FSK binario por USRP 2920
    generate_options: qt_gui
    id: Transmisor_FSK_USRP
    output_language: python
    title: Transmisor FSK - USRP 2920
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Misma tasa para el modulador y el USRP
      (100 MHz / 100 = 1 MS/s, valida en el 2920)
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Muestras por simbolo
    value: '100'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Frecuencia portadora
    value: 870e6
  states: {}
- name: fsk_deviation
  id: variable_qtgui_range
  parameters:
    label: Desviación FSK (Hz)
    start: '5000'
    step: '1000'
    stop: '100000'
    value: '20000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'Ganancia TX del 2920 (WBX): 0 a 31.5 dB'
    label: Ganancia TX (dB)
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    comment: Amplitud digital (<1 para no saturar el DAC)
    label: Amplitud
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.7'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: bit_source
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0,1,0,0,1,1,0,1,1,1,0,0,1,0,1,0]'
  states: {}
- name: nrz_mapper
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      bit 0 -> -1 (fc - desviacion)
      bit 1 -> +1 (fc + desviacion)
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: symbol_repeat
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: fsk_modulator
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*fsk_deviation/samp_rate
  states: {}
- name: amp_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    comment: 'USRP 2920: sin GPSDO -> Sync = none'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: tx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: fc
    fftsize: '2048'
    grid: 'True'
    label1: Tx
    name: '"Espectro FSK transmitido"'
    type: complex
  states: {}

connections:
- [bit_source, '0', nrz_mapper, '0']
- [nrz_mapper, '0', symbol_repeat, '0']
- [symbol_repeat, '0', fsk_modulator, '0']
- [fsk_modulator, '0', amp_scale, '0']
- [amp_scale, '0', uhd_usrp_sink_0, '0']
- [amp_scale, '0', tx_spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
